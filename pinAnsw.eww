<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AnswPin.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Backup of AnswPin.ewp</path>
    </project>
    <batchBuild />
</workspace>
